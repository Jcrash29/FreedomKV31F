# IAR project FreedomKV31F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; USING_NCN8025_INTERFACE=1; FRDM_KV31F; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../platform/osa/inc; ..\..\..\..\../platform/utilities/inc; ..\..\..\..\../platform/CMSIS/Include; ..\..\..\..\../platform/devices; ..\..\..\..\../platform/devices/MKV31F51212/include; ..\..\..\..\../platform/devices/MKV31F51212/startup; ..\..\..\..\../platform/hal/inc; ..\..\..\..\../platform/drivers/inc; ..\..\..\..\../platform/system/inc; ../../..; ../board; ..\..\..\..\../platform/drivers/src/adc16; ..\..\..\..\../platform/drivers/src/cmp; ..\..\..\..\../platform/drivers/src/crc; ..\..\..\..\../platform/drivers/src/dac; ..\..\..\..\../platform/drivers/src/dspi; ..\..\..\..\../platform/drivers/src/edma; ..\..\..\..\../platform/drivers/src/ewm; ..\..\..\..\../platform/drivers/src/flexbus; ..\..\..\..\../platform/drivers/src/ftm; ..\..\..\..\../platform/drivers/src/gpio; ..\..\..\..\../platform/drivers/src/i2c; ..\..\..\..\../platform/drivers/src/lptmr; ..\..\..\..\../platform/drivers/src/lpuart; ..\..\..\..\../platform/drivers/src/pdb; ..\..\..\..\../platform/drivers/src/pit; ..\..\..\..\../platform/drivers/src/rnga; ..\..\..\..\../platform/drivers/src/uart; ..\..\..\..\../platform/drivers/src/vref; ..\..\..\..\../platform/drivers/src/wdog; ..\..\..\..\../platform/drivers/src/smartcard; ..\..\..\..\../platform/drivers/src/smartcard/interface
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: FreedomKV31F.out
  ILINK.IlinkIcfFile: ..\..\..\..\../platform/devices/MKV31F51212/linker/iar/MKV31F512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\../lib/ksdk_platform_lib/iar/KV31F51212/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKV31F512VLL12; USING_NCN8025_INTERFACE=1; FRDM_KV31F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../platform/devices/MKV31F51212/startup/iar/: startup_MKV31F51212.s
    ../../../../../platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group sources
    ../: main.c main.h
  group board
    ../board/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c
    ../../../../../platform/utilities/inc/: fsl_debug_console.h print_scan.h
