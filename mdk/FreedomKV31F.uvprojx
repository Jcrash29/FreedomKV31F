# Keil uVision project FreedomKV31F.uvprojx, settings and files
target FreedomKV31F Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  output: FreedomKV31F.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, state, name
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ../../..; ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MKV31F51212/include; ../../../../../platform/devices/MKV31F51212/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../; ../board; ../../../../../platform/drivers/src/adc16; ../../../../../platform/drivers/src/cmp; ../../../../../platform/drivers/src/crc; ../../../../../platform/drivers/src/dac; ../../../../../platform/drivers/src/dspi; ../../../../../platform/drivers/src/edma; ../../../../../platform/drivers/src/ewm; ../../../../../platform/drivers/src/flexbus; ../../../../../platform/drivers/src/ftm; ../../../../../platform/drivers/src/gpio; ../../../../../platform/drivers/src/i2c; ../../../../../platform/drivers/src/lptmr; ../../../../../platform/drivers/src/lpuart; ../../../../../platform/drivers/src/pdb; ../../../../../platform/drivers/src/pit; ../../../../../platform/drivers/src/rnga; ../../../../../platform/drivers/src/uart; ../../../../../platform/drivers/src/vref; ../../../../../platform/drivers/src/wdog; ../../../../../platform/drivers/src/smartcard; ../../../../../platform/drivers/src/smartcard/interface
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x80000
  memory RVCT9: RAM 0x1FFF8000 size 0x00008000
  memory RVCT10: RAM 0x20000000 size 0x00010000
  scatter file: ../../../../../platform/devices/MKV31F51212/linker/arm/MKV31F512xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV31F51212/debug/libksdk_platform.lib
  group startup
    ../../../../../platform/devices/MKV31F51212/startup/arm/: startup_MKV31F51212.s
    ../../../../../platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group sources
    ../: main.c main.h
  group board
    ../board/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
target FreedomKV31F Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  output: FreedomKV31F.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: state, name
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x80000
  memory RVCT9: RAM 0x1FFF8000 size 0x00008000
  memory RVCT10: RAM 0x20000000 size 0x00010000
  scatter file: as above
  link misc: as above
